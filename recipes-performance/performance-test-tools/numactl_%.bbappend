# Copyright (C) 2021, Alliander
# SPDX-License-Identifier: Apache-2.0

DISABLE_STATIC = ""

